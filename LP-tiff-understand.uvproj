# Keil uVision project LP-tiff-understand.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1752 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LP-tiff-understand
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group Source Group 1
    ./: startup_LPC17xx.s
  group TIFF_codec
    ./TIFF_codec/: tiff_my.c tif_codec.c tif_fax3.c tif_fax3sm.c
  group Source
    ./source/: main.c
  group libtiff
    ./TIFF_codec/: tif_aux.c tif_close.c tif_color.c tif_compress.c tif_dir.c tif_dirinfo.c tif_dirread.c tif_dirwrite.c tif_dumpmode.c tif_error.c tif_extension.c tif_flush.c tif_getimage.c tif_jbig.c tif_jpeg.c tif_jpeg_12.c tif_luv.c tif_lzma.c tif_lzw.c tif_next.c tif_ojpeg.c tif_open.c tif_packbits.c tif_pixarlog.c tif_predict.c tif_print.c tif_read.c tif_strip.c tif_swab.c tif_thunder.c tif_tile.c tif_unix.c tif_version.c tif_warning.c tif_write.c
  group tools
    ../tiff-4.0.3/tools/: tiffsplit.c tiff2bw.c tiff2pdf.c tiff2ps.c tiff2rgba.c tiffcmp.c tiffcp.c tiffcrop.c tiffdither.c tiffdump.c tiffgt.c tiffinfo.c tiffmedian.c tiffset.c bmp2tiff.c fax2tiff.c
