# Keil uVision project fax3_tables.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1752 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IROM(0-0x0FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: fax3_tables
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group Source Group 1
    ./: mkg3states.c
  group Asm
    ../../LP-tiff-f4/: startup_LPC17xx.s
